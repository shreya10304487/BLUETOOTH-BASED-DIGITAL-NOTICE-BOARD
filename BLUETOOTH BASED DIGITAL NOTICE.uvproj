# Keil uVision project BLUETOOTH BASED DIGITAL NOTICE.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2129 NXP
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: BLUETOOTH BASED DIGITAL NOTICE +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source Group 1
    ./: Startup.s 74LS164.c delays.c dml.c main.c 74LS164.h defines.h delays.h dml.h uart.h uart.c i2c.c i2c.h i2c_defines.h i2c_eeprom.h i2c_eeprom.c types.h
